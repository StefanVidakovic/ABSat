# IAR project I2C_Master_Slave.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 SiliconLaboratories EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128
  ICCARM.CCIncludePath2: ..\..\..\platform\CMSIS\Include; ..\..\..\platform\Device\SiliconLabs\EFM32G\Include; ..\..\..\platform\emlib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32G890F128
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: I2C_Master_Slave.bin
  ILINK.IlinkOutputFile: I2C_Master_Slave.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../platform/emlib/src/: em_system.c em_cmu.c em_rtc.c em_gpio.c em_i2c.c em_emu.c
  group Source
    ../: i2c_master_slave.c
