# IAR project I2C_Tempsens.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 SiliconLaboratories EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128
  ICCARM.CCIncludePath2: ..\..\..\platform\CMSIS\Include; ..\..\..\platform\Device\SiliconLabs\EFM32G\Include; ..\..\..\platform\emlib\inc; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\common\drivers; ..\..\..\hardware\kit\EFM32_Gxxx_DK\config; ..\..\..\platform\emdrv\rtcdrv\inc; ..\..\..\platform\emdrv\rtcdrv\config; ..\..\..\platform\emdrv\common\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32G890F128
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: I2C_Tempsens.bin
  ILINK.IlinkOutputFile: I2C_Tempsens.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group BSP
    ../../../hardware/kit/common/bsp/: bsp_dk_3200.c
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group drivers
    ../../../hardware/kit/common/drivers/: segmentlcd.c
    ../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group emlib
    ../../../platform/emlib/src/: em_system.c em_cmu.c em_rtc.c em_core.c em_gpio.c em_lcd.c em_usart.c em_i2c.c em_emu.c
  group Source
    ../: i2c_tempsens_main.c i2c_tempsens.c
