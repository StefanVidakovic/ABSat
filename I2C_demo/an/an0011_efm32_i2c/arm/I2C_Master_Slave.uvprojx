# Keil uVision project I2C_Master_Slave.uvprojx, settings and files
target I2C_Master_Slave (ARM-ADS)
  device: EFM32G890F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: I2C_Master_Slave
  AfterMake: fromelf.exe --bin --output obj\I2C_Master_Slave.bin obj\I2C_Master_Slave.axf
  c flags: Optim=1 oTime=1
  c define: EFM32G890F128
  c misc: --c99
  c include: ..\;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32G\Include;..\..\..\platform\emlib\inc
  asm define: EFM32G890F128
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../platform/emlib/src/: em_system.c em_cmu.c em_rtc.c em_gpio.c em_i2c.c em_emu.c
  group Source
    ../: i2c_master_slave.c
