# Keil uVision project I2C_Tempsens.uvprojx, settings and files
target I2C_Tempsens (ARM-ADS)
  device: EFM32G890F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: I2C_Tempsens
  AfterMake: fromelf.exe --bin --output obj\I2C_Tempsens.bin obj\I2C_Tempsens.axf
  c flags: Optim=1 oTime=1
  c define: EFM32G890F128
  c misc: --c99
  c include: ..\;..\..\..\platform\CMSIS\Include;..\..\..\platform\Device\SiliconLabs\EFM32G\Include;..\..\..\platform\emlib\inc;..\..\..\hardware\kit\common\bsp;..\..\..\hardware\kit\common\drivers;..\..\..\hardware\kit\EFM32_Gxxx_DK\config;..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\platform\emdrv\rtcdrv\config;..\..\..\platform\emdrv\common\inc
  asm define: EFM32G890F128
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group BSP
    ../../../hardware/kit/common/bsp/: bsp_dk_3200.c
  group CMSIS
    ../../../platform/Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group drivers
    ../../../hardware/kit/common/drivers/: segmentlcd.c
    ../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group emlib
    ../../../platform/emlib/src/: em_system.c em_cmu.c em_rtc.c em_core.c em_gpio.c em_lcd.c em_usart.c em_i2c.c em_emu.c
  group Source
    ../: i2c_tempsens_main.c i2c_tempsens.c
